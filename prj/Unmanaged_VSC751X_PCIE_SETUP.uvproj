# Keil uVision project Unmanaged_VSC751X_PCIE_SETUP.uvproj, settings and files
target OCELOT_PCIE_BRINGUP (MCS-51)
  device: VSC7420 Vitesse
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Ocelot_PCIe_Setup +hex
  c flags: Optimize=9
  c define: VTSS_ARCH_OCELOT OCELOT_6P PROJ_OPT=99999
  c include: c:\keil\c51\inc\winbond;..\src\config;..\src\config\proj_opt;..\src\cli;..\src\main;..\src\switch;..\src\phy;..\src\util;..\src\switch\vtss_api\base;..\src\switch\vtss_api\base\ocelot;..\src\switch\include;..\src\lldp;..\src\snmp;..\src\sw_lacp;..\src\eee;..\src\eee\base\include;..\src\fan;..\src\led;..\src\loop
  asm include: ..\src\config
  group main
    ../src/main/: uartdrv.c timer.c interrupt.c main.c sysutil.c STARTUP_OCELOT.A51 vtss_os.c
  group switch
    ../src/switch/: h2ioutil.c h2.c h2io.a51 h2pcs1g.c h2sdcfg.c h2gpios.c
  group cli
    ../src/cli/: txt.c print.c txt_moredef.c
  group config
    ../src/config/: version.c hwport.c
  group util
    ../src/util/: misc2.a51 misc3.a51 misc1.c
  group led
    ../src/led/: ledtsk.c
